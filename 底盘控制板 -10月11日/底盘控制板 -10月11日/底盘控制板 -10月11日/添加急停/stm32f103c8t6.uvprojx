# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Startup;.\User;.\Library;.\User_Fun;.\freertos\include;.\freertos\port\RVDS\ARM_CM3;.\Hardware\RC522;.\Hardware\TCS3472;.\Hardware\TIMER;.\Hardware\vl6180x;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./Startup/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h startup_stm32f10x_hd.s
  group library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group user
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h main.c BACKUP.c
  group freertos_port
    ./freertos/port/MemMang/: heap_4.c
    ./freertos/port/RVDS/ARM_CM3/: port.c
  group freertos_src
    ./freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Hardware/: usart.c usart.h
  group Hardware
    ./Hardware/: LED.c LED.h Delay.c Delay.h sys.h HallEncoder.c HallEncoder.h PWM.c PWM.h OLED.c OLED.h OLED_Font.h Servo.c Servo.h Key.c Key.h
    ./Hardware/RC522/: rc522_config.c rc522_config.h rc522_function.c rc522_function.h
    ./Hardware/TCS3472/: tcs34725.c tcs34725.h
    ./Hardware/TIMER/: timer.c timer.h
    ./Hardware/vl6180x/: VL6180.c VL6180.h
